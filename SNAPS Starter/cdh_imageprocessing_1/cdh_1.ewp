# IAR project cdh_1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_EMBEDDED_PHY; USE_USB_OTG_FS; USE_DEVICE_MODE; USB_SUPPORT_USER_STRING_DESC
  ICCARM.CCIncludePath2: $PROJ_DIR$; src\; src\USB\; ..\lib\CMSIS-F4\Include; ..\lib\CMSIS-F4\Device\ST\STM32F4xx\Include; ..\lib\fat_sd; ..\lib\STM32_USB_Device_Library\Core\inc; ..\lib\STM32_USB_OTG_Driver\inc; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\lib\freertos-7.1.1\include; ..\lib\freertos-7.1.1\portable\IAR\ARM_CM4F; ..\lib\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; inc; src; ..\lib\CMSIS-F4\Include; ..\lib\CMSIS-F4\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\lib\freertos-7.1.1\include; ..\lib\freertos-7.1.1\portable\IAR\ARM_CM4F; ..\lib\drivers
  OBJCOPY.OOCOutputFile: cdh_1.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f4xx_flash_wSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group fat_sd
    ../lib/fat_sd/: fattime.c ff.c sd_spi_stm32.c
  group fat_sd/option
    ../lib/fat_sd/option/: unicode.c
  group FreeRTOS
    ../lib/freertos-7.1.1/: list.c queue.c tasks.c
    ../lib/freertos-7.1.1/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ImageProcessing
    ../lib/ImageProcessing/: earthfind.h filemanager.c filemanager.h image.c image.h populatearray.c populatearray.h sortimagearray.c sortimagearray.h
  group ImageProcessing/Converter
    ../lib/ImageProcessing/Converter/: fillpixelmatrix.c fillpixelmatrix.h
  group ImageProcessing/Encoder
    ../lib/ImageProcessing/Encoder/: bmp2jpg.c bmp2jpg.h ColorConversion.c ColorConversion.h dct.c dct.h ejpgl.h huffman.c huffman.h jpeg.c jpeg.h zzq.c zzq.h
  group ImageProcessing/Filters
    ../lib/ImageProcessing/Filters/: circledetect.c circledetect.h edgedetect.c edgedetect.h histogram.c histogram.h
  group ImageProcessing/H264Decoder
    ../lib/ImageProcessing/H264Decoder/: bitstream.c bitstream.h bitstream_types.h cabac.c cabac.h cabac_data.h common.h decode.c decode.h decode_image.c decode_image_intra.h decode_slice.c decode_slice.h defaulttables.c defaulttables.h filter_image.c intmath.c intmath.h inverse_transforms.h lud.c ludh264.c ludh264.h output.c syntax.c syntax.h syntax_types.h sysinfo.h system.c system.h
  group ImageProcessing/H264Parser
    ../lib/ImageProcessing/H264Parser/: avccparser.c avccparser.h commonparser.h iframeparser.c iframeparser.h
  group ImageProcessing/Packets
    ../lib/ImageProcessing/Packets/: packet.c packet.h
  group STM32_USB_Device_Library
    ../lib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32_USB_OTG_Driver
    ../lib/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group STM32F4xx_StdPeriph_Driver
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    src/: main.c stm32f4xx_it.c system_stm32f4xx.c util.c
    ../lib/CMSIS-F4/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group User/stm32f4
    src/stm32f4/: adc.c boost.c camera.c core.c fram.c radio.c sram.c
  group User/USB
    src/USB/: usb_bsp.c usb_controller.c usb_controller.h usbd_cdc_vcp.c usbd_composite_core.c usbd_desc.c usbd_usr.c
