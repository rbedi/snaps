# IAR project basic_spi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: $PROJ_DIR$; src\; inc\; ..\lib\CMSIS-F4\Include; ..\lib\CMSIS-F4\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\lib\freertos-7.1.1\include; ..\lib\freertos-7.1.1\portable\IAR\ARM_CM4F; ..\lib\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; inc; src; ..\lib\CMSIS-F4\Include; ..\lib\CMSIS-F4\Device\ST\STM32F4xx\Include; ..\lib\STM32F4xx_StdPeriph_Driver\inc; ..\lib\freertos-7.1.1\include; ..\lib\freertos-7.1.1\portable\IAR\ARM_CM4F; ..\lib\drivers
  OBJCOPY.OOCOutputFile: basic_spi.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: ..\lib\CMSIS-F4\Device\ST\STM32F4xx\Source\Templates\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group FreeRTOS
    ../lib/freertos-7.1.1/: list.c queue.c tasks.c
    ../lib/freertos-7.1.1/portable/IAR/ARM_CM4F/: port.c portasm.s
  group PeriphLib
    ../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    src/: config.c main.c spi.c stm32f4xx_it.c system_stm32f4xx.c
    ../lib/CMSIS-F4/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
